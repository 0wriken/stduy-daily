# Keil uVision project stm32f103c8t6.uvprojx, settings and files
target stm32f103c8t6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103c8t6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD
  c include: .\cmsis\inc;.\user\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group cmsis
    ./cmsis/src/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_md.s
  group user
    ./user/src/: main.c led.c key.c usart.c time.c pwm_out.c pwm_in.c dma_usart.c dma_memory.c
    ./user/inc/: main.h led.h usart.h pwm_out.h pwm_in.h dma_usart.h dma_memory.h

# Keil uVision project project_demo.uvprojx, settings and files
target project_demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project_demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx
  c include: .\cmsis\inc;.\user\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group cmsis
    ./cmsis/src/: stm32f4xx_it.c startup_stm32f40_41xxx.s system_stm32f4xx.c
    ./cmsis/inc/: stm32f4xx.h
  group user
    ./user/src/: main.c led.c key.c delay.c uart.c key_interrupt.c watchdog.c systick.c time.c pwm_out.c pwm_in.c DMA_USART.C
    ./user/inc/: dma_usart.h
